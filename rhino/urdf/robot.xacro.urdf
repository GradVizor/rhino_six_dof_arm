Commit message: added camera and colour detection scripts

File: rhino/urdf/robot.xacro.urdf (robot description, URDF)
Before this commit: robot rhino, 9 links, 8 joints
Links:
- link link5: mass 0.16763744128735503 -> 0.12333
